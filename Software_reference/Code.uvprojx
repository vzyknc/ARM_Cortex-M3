# Keil uVision project Code.uvprojx, settings and files
target DesignStart (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Code +hex
  AfterMake: fromelf -cvf .\objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\objects\code.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Files
    ./: main.c cmdsasm.s
